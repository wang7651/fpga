# Keil uVision project gd6101.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: gd6101 +hex
  c flags: Optimize=3 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./source/: gd6101.c gd6101_reg.src STARTUP.src STARTUP.A51
    ./Objects/: gd6101.SRC
target asm (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: gd6101 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
target asm2 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: gd6101 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
